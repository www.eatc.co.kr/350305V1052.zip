# Autodesk Inventor part: 가변 스프링
## iProperties
Created: 2015-03
Part Number: 가변 스프링
Document SubType Name: Modeling
Designer: Administrator
Density: 1 g/cm^3
Author: Administrator
